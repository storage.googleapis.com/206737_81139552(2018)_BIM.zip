Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: e894146a-4833-4a84-92aa-b003607abd5d, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 81139552(2025).ifc
Time: 2025-05-20T22:53:29
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum (2)
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Circle Head - Project Datum; Type: Circle Head - Project Datum; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle : Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum
Other(Type) - Category: Levels; Family Name: Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
Level 0 | Level 0 | 0
Level 1 | Level 1 | 4000

# IfcFlowController: 81139552(2025):81139552 Cover part for shower faucet, 81139552(2025):81139552 Cover part for shower faucet:375820
In: Level 0
Type - PredefinedType: FAUCET; Material: Brass
Type - General - Author: BIMStone; BIMObjectName: 81139552(2018); ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_10; Uniclass2015Description: Bath thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_10; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - Approval ABP: PA-IX 38187/IC; Approval DVGW: DW-6509CS0197; CO2 Emissions (A1-A3): 24.15; CO2 Emissions (A4): 0.4; CO2 Emissions (B7): 3937.2; CO2 Emissions (C2): 0.02; CO2 Emissions (C3): 0.02; CO2 Emissions (C4): 0.32; CO2 Emissions (D): -7.47; EN Standard: EN 1111; ETIM Class Number: EC010546 Mechanical control system for shower; Noise Class: I (ISO 3822); UNSPSC Class Number: 30181810 Faucet trim; URL ABP: http://static.hansa.com/ABP/81139552; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/81139552; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL DVGW: http://static.hansa.com/DVGW/81139552; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL Environmental Product Declaration EPD: http://static.hansa.com/EPD/81139552; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL Materials Declaration: http://www.hansa.com/fileadmin/resources/169425_81139552_materialsdeclaration.pdf; URL REACH: http://static.hansa.com/doc/reach
Type - Constraints - Default Elevation: 0 mm
Type - Mechanical - Advanced Features: Inner body made of DZR brass; Backflow Prevention EN1717: EB; Concealed Parts: BLUECLICK for an easy, screwless trim plate installation;BLUETUNE alignment after installation of +/- 3,5º;Function unit;Fastening of the function unit with screws;Rosette plate frame;Round rosette;Sleeve; Flow Rate At 300kPa: 0.34 dm3/s; Installation Type: Concealed wall mounting; Lever Handle: Temperature control handle;Flow control handle; Max. Hot Water Supply: 80 C; Mechanical Parts: Thermostatic cartridge for automatic temperature control;Ceramic head part for flow control;Non-return valve(s); Surface treatment: Chrome; Temperature Adjustments: Safety stop against scalding at 38°C; Working Pressure: 50 - 1000 kPa
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Dimensions - NominalDepth: 72.5097 mm; NominalHeight: 201.339 mm; NominalWidth: 169.617 mm
Type - Identity Data - 3D View: https://static.hansa.com/3D/81139552; Ambience photo: http://static.hansa.com/ambience/81139552; Catalog Drawing URL: http://static.hansa.com/catdrw/81139552; Category B2C: Shower solutions; Color variants: 8113955233;8113955280;8113955281; Dimension Drawing URL: http://static.hansa.com/dimdrw/81139552; FDV Document URL: http://www.hansa.com/datasheet/81139552/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/81139552; Group: Shower faucet; Installation and Maintenance Guide URL: http://static.hansa.com/manual/81139552; Interactive AR View URL: https://static.hansa.com/AR/81139552; Manufacturer: HANSA; Market: Austria;Belgium;Czech Republic;Germany;Spain;France;International;Italy;Netherlands;Slovakia; Mobile Product Information URL: http://mpi.hansa.com/81139552; Model: 81139552 Cover part for shower faucet; Name_en: 81139552 Cover part for shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 81139552; Product Family: HANSALIVING; Product Image URL: http://static.hansa.com/image/81139552; Product URL: http://static.hansa.com/81139552; Spare-Part Information URL: http://static.hansa.com/sp/81139552; Technical DataSheet URL: http://www.hansa.com/datasheet/81139552/en; Type Name: 81139552 Cover part for shower faucet; Warranty Information URL: http://warranty.hansa.com
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 81139552(2025); Features: Trim Kit;Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 81139552; Name: 81139552 Cover part for shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 170x75x200 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Material: <Unnamed>
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 0; Level: Level 0; Moves With Nearby Elements: no; Offset from Host: 0 mm
Phasing - Phase Created: New Construction
Dimensions - Area: 0.0610484 m2; Volume: 0.00247624 m3
Identity Data - Mark: 25
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 81139552(2025); Family and Type: 81139552(2025): 81139552 Cover part for shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 81139552 Cover part for shower faucet; Type Id: 375804; WarrantyStartDate: n/a
